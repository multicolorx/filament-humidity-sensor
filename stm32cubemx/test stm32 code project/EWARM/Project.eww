<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test stm32 code project.ewp</path>
  </project>
  <batchBuild />
</workspace>
